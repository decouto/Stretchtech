# Keil uVision project Putz01.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Putz01
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Putz01;.\RTE\Device\STM32F429ZITx\STCubeGenerated\Drivers\STM32F4xx_HAL_Driver\Inc;.\RTE\Device\STM32F429ZITx\STCubeGenerated\Inc;C:\Keil_v5\ARM\Pack\Keil\STM32F4xx_DFP\2.5.0\Drivers\STM32F4xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Putz01
    ./: Putz01.cpp
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F429ZITx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F429ZITx/STCubeGenerated/Inc/: stm32f4xx_it.h
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Compiler:I/O:STDIN 1.0.0, Compiler:I/O:STDOUT 1.0.0, Device:STM32Cube HAL:Common 1.3.1, Device:STM32Cube HAL:Cortex 1.3.1, Device:STM32Cube HAL:DMA 1.3.1, Device:STM32Cube HAL:DMA2D 1.3.1, Device:STM32Cube HAL:GPIO 1.3.1, Device:STM32Cube HAL:I2C 1.3.1, Device:STM32Cube HAL:I2S 1.3.1, Device:STM32Cube HAL:LTDC 1.3.1, Device:STM32Cube HAL:PWR 1.3.1, Device:STM32Cube HAL:RCC 1.3.1, Device:STM32Cube HAL:SAI 1.3.1, Device:STM32Cube HAL:UART 1.3.1, Device:STM32Cube HAL:USART 1.3.1, Device:Startup 2.3.1
